//
// Created by zhangyucong on 2023/11/4.
//

#include "foc_utils.h"
/***************************************************************************/
/*
 * foc_utils.c 放一些 FOC 会反复使用的数学工具。
 *
 * 单片机上直接调用 sinf()/sqrtf() 有时比较慢。
 * 这里用“查表正弦”和“快速平方根近似”来减少计算时间。
 */

// 正弦表只存 0~PI/2，也就是第一象限，共 200 个点。
// 表中的值是 sin(x) * 10000 后转成整数，节省 Flash 空间。
// 其它象限利用正弦函数对称性换算得到。
const int sine_array[200] = {0,79,158,237,316,395,473,552,631,710,789,867,946,1024,1103,1181,1260,1338,1416,1494,1572,1650,1728,1806,1883,1961,2038,2115,2192,2269,2346,2423,2499,2575,2652,2728,2804,2879,2955,3030,3105,3180,3255,3329,3404,3478,3552,3625,3699,3772,3845,3918,3990,4063,4135,4206,4278,4349,4420,4491,4561,4631,4701,4770,4840,4909,4977,5046,5113,5181,5249,5316,5382,5449,5515,5580,5646,5711,5775,5839,5903,5967,6030,6093,6155,6217,6279,6340,6401,6461,6521,6581,6640,6699,6758,6815,6873,6930,6987,7043,7099,7154,7209,7264,7318,7371,7424,7477,7529,7581,7632,7683,7733,7783,7832,7881,7930,7977,8025,8072,8118,8164,8209,8254,8298,8342,8385,8428,8470,8512,8553,8594,8634,8673,8712,8751,8789,8826,8863,8899,8935,8970,9005,9039,9072,9105,9138,9169,9201,9231,9261,9291,9320,9348,9376,9403,9429,9455,9481,9506,9530,9554,9577,9599,9621,9642,9663,9683,9702,9721,9739,9757,9774,9790,9806,9821,9836,9850,9863,9876,9888,9899,9910,9920,9930,9939,9947,9955,9962,9969,9975,9980,9985,9989,9992,9995,9997,9999,10000,10000};

/***************************************************************************/
/*
 * 使用查表方式近似计算 sin(a)。
 *
 * 输入要求：
 *   a 必须已经被限制在 0~2PI。
 *
 * 输出：
 *   近似的 sin(a)，误差大约在 0.005 量级。
 */
float _sin(float a){
    if(a < _PI_2){
        // 第一象限：直接查表。126.6873 约等于 199 / (PI/2)。
        return 0.0001*sine_array[_round(126.6873* a)];      // int array optimized
    }else if(a < _PI){
        // 第二象限：sin(PI - x) = sin(x)，所以反向查表。
        return 0.0001*sine_array[398 - _round(126.6873*a)];     // int array optimized
    }else if(a < _3PI_2){
        // 第三象限：正弦为负，形状与第一象限相同。
        return -0.0001*sine_array[-398 + _round(126.6873*a)];      // int array optimized
    } else {
        // 第四象限：正弦为负，形状与第二象限相同。
        return -0.0001*sine_array[796 - _round(126.6873*a)];      // int array optimized
    }
}
/***************************************************************************/
// 把任意弧度角归一化到 [0, 2PI)。
float _normalizeAngle(float angle){
    // fmod 得到除以 2PI 后的余数；如果是负数，再补一个 2PI。
    float a = fmod(angle, _2PI);
    return a >= 0 ? a : (a + _2PI);
}
/***************************************************************************/
// 计算未校零的电角度：电角度 = 机械角度 * 极对数。
float _electricalAngle(float shaft_angle, int pole_pairs) {
    return (shaft_angle * pole_pairs);
}
/***************************************************************************/
/*
 * 快速平方根近似。
 *
 * 这个算法来自经典的 fast inverse square root 思路：
 *   先快速近似 1/sqrt(number)，再乘以 number，得到 sqrt(number)。
 *
 * 优点：快。
 * 缺点：有误差；本工程用于 SVPWM 电压幅值估算，通常可以接受。
 */
float _sqrtApprox(float number) {//low in fat
    long i;
    float y;
    // float x;
    // const float f = 1.5F; // better precision

    // x = number * 0.5F;
    y = number;
    i = * ( long * ) &y;
    i = 0x5f375a86 - ( i >> 1 );
    y = * ( float * ) &i;
    // y = y * ( f - ( x * y * y ) ); // better precision
    // number * (1/sqrt(number)) 约等于 sqrt(number)。
    return number * y;
}
/***************************************************************************/
